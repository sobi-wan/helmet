FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"
SRC_URI += "file://0001-DVP-ov5640-camera-fix.patch"
SRC_URI += "file://0001-Initial-helmet-device-tree-changes.patch"
